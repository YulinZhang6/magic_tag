# Keil uVision project ctnb.uvprojx, settings and files
target ctnb (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ctnb
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\bsp;..\bsp\util;..\user;..\RTOS\TinyPrintf;..\RTOS\thread-os\log;..\RTOS\thread-os\config;..\RTOS\thread-os\core;..\RTOS\thread-os\lib;..\RTOS\thread-os\port;..\RTOS\thread-os\FlexShell;../system/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\gps;..\EPD_W21;..\paint
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group profile
    ../user/: app_aep_profile.c app_aep_profile.h AepServiceCodes.c AepServiceCodes.h
  group user
    ../user/: user_main.c user_main.h bsp_thread.c bsp_thread.h BC28_thread.c BC28_thread.h nb_thread.c nb_thread.h userconfig.h report_thread.c report_thread.h
  group BSP
    ../bsp/: bsp.c bsp.h delay.c delay.h led.c led.h motor.c motor.h HTS221.c HTS221.h app_uart.c app_uart.h log_uart.c log_uart.h
  group util
    ../bsp/util/: md5.c md5.h util.c util.h
  group FlexShell
    ../RTOS/thread-os/FlexShell/: Csection.h FlexShell.c FlexShell.h FlexShell_port.c FlexShell_port.h FlexShellSys.c FlexShellUser.c
  group log
    ../RTOS/TinyPrintf/: TinyPrintf.c TinyPrintf.h
    ../RTOS/thread-os/log/: TinyLog.c TinyLog.h
  group thread-os
    ../RTOS/thread-os/config/: os_config.h
    ../RTOS/thread-os/core/: thread.c thread.h os_core.c os_core.h os_event.c os_event.h os_fifo.c os_fifo.h os_sem.c os_sem.h os_soft_timer.c os_soft_timer.h os_time.c os_time.h
    ../RTOS/thread-os/port/: os_port.c os_port.h
    ../RTOS/thread-os/lib/: fifo.c fifo.h
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_uart.c
  group system
    ../system/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group system_CMSIS
    ../system/Src/: system_stm32f1xx.c
  group startup
    ./: startup_stm32f103xb.s
  group EPD_W21
    ../EPD_W21/: epd_w21.c image_buffer.c
  group gps
    ../gps/: gps_parse.c
  group paint
    ../paint/: GUI_Paint.c font20.c font16.c
software components: CMSIS:CORE 5.1.2
